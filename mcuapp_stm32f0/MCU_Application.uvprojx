# Keil uVision project MCU_Application.uvprojx, settings and files
target Target 1 (ARM-ADS)
  device: STM32F071VBTx STMicroelectronics
  pack: Keil.STM32F0xx_DFP.2.0.0
  cpu: IROM(0x08000000,0x00020000) IRAM(0x20000000,0x00004000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: MCU_Application
  c flags: Optim=1 OneElfS=1 uC99=1 wLevel=2
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x4000
  group Source
    ./: main.c hal.c adf435x.c hmcad151x.c shell.c shell_commands.c zynq_spi.c
  group Headers
    ./: zynq_spi.h hal.h adf435x.h hmcad151x.h shell.h shell_commands.h
  group Libraries
    ./microrl/src/: microrl.c
software components: CMSIS:CORE 5.1.2, Device:STM32Cube HAL:ADC 1.7.0, Device:STM32Cube HAL:CAN 1.7.0, Device:STM32Cube HAL:CEC 1.7.0, Device:STM32Cube HAL:COMMON 1.7.0, Device:STM32Cube HAL:COMP 1.7.0, Device:STM32Cube HAL:CORTEX 1.7.0, Device:STM32Cube HAL:CRC 1.7.0, Device:STM32Cube HAL:DAC 1.7.0, Device:STM32Cube HAL:DMA 1.7.0, Device:STM32Cube HAL:FLASH 1.7.0, Device:STM32Cube HAL:GPIO 1.7.0, Device:STM32Cube HAL:I2C 1.7.0, Device:STM32Cube HAL:I2S 1.7.0, Device:STM32Cube HAL:IRDA 1.7.0, Device:STM32Cube HAL:IWDG 1.7.0, Device:STM32Cube HAL:PCD 1.7.0, Device:STM32Cube HAL:PWR 1.7.0, Device:STM32Cube HAL:RCC 1.7.0, Device:STM32Cube HAL:RTC 1.7.0, Device:STM32Cube HAL:SMARTCARD 1.7.0, Device:STM32Cube HAL:SMBUS 1.7.0, Device:STM32Cube HAL:SPI 1.7.0, Device:STM32Cube HAL:TIM 1.7.0, Device:STM32Cube HAL:TSC 1.7.0, Device:STM32Cube HAL:UART 1.7.0, Device:STM32Cube HAL:USART 1.7.0, Device:STM32Cube HAL:WWDG 1.7.0, Device:Startup 1.0.0
